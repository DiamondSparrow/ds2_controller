# Keil uVision project ds2_controller.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ds2_controller +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Release\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_M3, __CC_ARM, NO_BOARD_LIB
  c include: ..\..\Code\APP;..\..\Code\APP\config;..\..\Code\Utils;..\..\Code\Startup;..\..\Code\ThirdParty\CMSIS\Include;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_15xx;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_15xx\config_15xx;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_common;..\..\Code\ThirdParty\RTX;..\..\Code\BSP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group APP
    ../../Code/APP/: app.c debug.c indication.c
  group APP/CLI
    ../../Code/APP/cli/: cli.c cli_app.c cli_cmd.c
  group APP/Config
    ../../Code/APP/Config/: RTX_Conf_CM.c
  group APP/Display
    ../../Code/APP/display/: fonts.c ssd1306.c
  group APP/Servo
    ../../Code/APP/servo/: servo.c
  group APP/Ultrasonic
    ../../Code/APP/ultrasonic/: ultrasonic.c
  group BSP
    ../../Code/BSP/: bsp.c gpio.c i2c.c pwm.c uart.c
  group Startup
    ../../Code/Startup/: keil_startup_lpc15xx.s sysinit.c
  group ThirdParty/lpc_chip_15xx
    ../../Code/ThirdParty/lpc_core/lpc_chip/chip_15xx/: acmp_15xx.c adc_15xx.c chip_15xx.c clock_15xx.c crc_15xx.c dac_15xx.c dma_15xx.c gpio_15xx.c i2c_common_15xx.c i2cm_15xx.c i2cs_15xx.c iocon_15xx.c pinint_15xx.c pmu_15xx.c ritimer_15xx.c rtc_15xx.c sct_15xx.c sct_pwm_15xx.c sctipu_15xx.c sysctl_15xx.c sysinit_15xx.c spi_15xx.c stopwatch_15xx.c swm_15xx.c uart_15xx.c wwdt_15xx.c
  group ThirdParty/lpc_chip_common
    ../../Code/ThirdParty/lpc_core/lpc_chip/chip_common/: eeprom.c iap.c ring_buffer.c rtc_ut.c
  group ThirdParty/RTX
    ../../Code/ThirdParty/RTX/: RTX_CM3.lib
